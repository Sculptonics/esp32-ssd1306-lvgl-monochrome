## sdkconfig.defaults
```kconfig
CONFIG_LV_COLOR_DEPTH=8
CONFIG_LV_OS_FREERTOS=y
CONFIG_LV_USE_LODEPNG=y
CONFIG_LV_LOG_PRINTF=y
CONFIG_LV_USE_LOG=y
CONFIG_LV_LOG_LEVEL_WARN=y
```
